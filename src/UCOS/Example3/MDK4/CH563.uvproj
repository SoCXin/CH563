# Keil uVision project CH563.uvproj, settings and files
target CH563 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STR911FAM44 STMicroelectronics
  cpu: IRAM(0x04000000-0x04017FFF) IROM(0x0-0x7FFFF) IROM2(0x400000-0x407FFF) CLOCK(25000000) CPUTYPE(ARM966E-S)
  output: CH563 +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c misc: --C99
  c include: ..\User;..\User\App;..\User\arm;..\..\PUB\ucosii;..\..\..\SRC
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x400000 size 0x8000
  memory RVCT9: RAM 0x4000000 size 0x18000
  scatter file: ..\..\..\SRC\CH563D64.SCF
  link misc: --entry Reset
  group user
    ../User/: MAIN.C
  group sys
    ../../../SRC/: SYSFREQ.C STARTUP.S
  group UCOS_II
    ../../PUB/ucosii/: OS_TIME.C OS_CORE.C OS_FLAG.C OS_MBOX.C OS_MEM.C OS_MUTEX.C OS_Q.C OS_SEM.C OS_TASK.C
  group ARM
    ../User/arm/: Os_cpu_c.c Os_cpu_a.s Os_int_a.s
  group APP
    ../User/App/: bsp.c
